options:
  parameters:
    generate_options: hb
    id: SDQ_hier
    output_language: python
    title: 1-Bit Sigma-Delta
  states: {}

blocks:
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr

      class sigma_delta_1bit(gr.sync_block):
          """
          1-Bit First-Order Sigma-Delta Quantizer
          Expects float32 input in the range [-1.0, 1.0].
          Outputs float32 values of either 1.0 or -1.0.
          """
          def __init__(self):
              # Initialize the sync block with 1 float input and 1 float output
              gr.sync_block.__init__(
                  self,
                  name="1-Bit Sigma-Delta",
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              
              # Internal state variables for the modulator loop
              self.integrator = 0.0
              self.last_out = 0.0

          def work(self, input_items, output_items):
              in0 = input_items[0]
              out = output_items[0]
              
              # Process sample-by-sample due to the feedback loop
              for i in range(len(in0)):
                  # 1. Calculate the error (Difference)
                  error = in0[i] - self.last_out
                  
                  # 2. Accumulate the error (Integrator)
                  self.integrator += error
                  
                  # 3. 1-bit Quantization (Comparator)
                  if self.integrator >= 0.0:
                      self.last_out = 1.0
                  else:
                      self.last_out = -1.0
                      
                  # Assign to output array
                  out[i] = self.last_out
                  
              return len(out)
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: Out_1B
    type: float
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: In
    type: float
  states: {}

connections:
- [epy_block_0, '0', pad_sink_0, '0']
- [pad_source_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
